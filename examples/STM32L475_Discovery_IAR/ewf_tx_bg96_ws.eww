<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ewf_info_tx_bg96\EWARM\ewf_info_tx_bg96.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\ewf_test_tx_bg96\EWARM\ewf_test_tx_bg96.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sample_threadx\EWARM\sample_threadx.ewp</path>
    </project>
    <batchBuild />
</workspace>
